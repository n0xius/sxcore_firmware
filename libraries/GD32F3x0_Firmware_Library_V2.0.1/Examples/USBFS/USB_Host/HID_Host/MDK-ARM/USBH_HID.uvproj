# Keil uVision project USBH_HID.uvproj, settings and files
target USBH_HID (ARM-ADS)
  device: GD32F350RB GigaDevice
  cpu: IRAM(0x20000000-0x20003FFF)IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: USBH-HID +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F350
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F3x0\Include;..\..\..\..\..\Firmware\CMSIS\GD;..\..\..\..\..\Firmware\GD32F3x0_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F3x0_usbfs_driver\Include;..\..\..\..\..\Utilities;..\..\..\..\..\Utilities\LCD_Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../src/: gd32f3x0_it.c main.c usb_delay.c usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_usr.c systick.c
  group CMSIS
    ../../../../../Firmware/GD32F3x0_usbfs_driver/Source/: system_gd32f3x0.c
  group GD32F3x0_Peripherals
    ../../../../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c gd32f3x0_spi.c
  group GD32F3x0_EVAL
    ../../../../../Utilities/LCD_Common/: lcd_log.c
    ../../../../../Utilities/: gd32f350r_eval.c gd32f3x0_lcd_eval.c
  group USB_Driver
    ../../../../../Firmware/GD32F3x0_usbfs_driver/Source/: usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c usb_core.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Doc
    ../: readme.txt
