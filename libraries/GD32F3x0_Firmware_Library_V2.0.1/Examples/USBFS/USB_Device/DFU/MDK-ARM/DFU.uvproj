# Keil uVision project DFU.uvproj, settings and files
target USBFS_DFU (ARM-ADS)
  device: GD32F350RB GigaDevice
  cpu: IRAM(0x20000000-0x20003FFF)IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: HID_DFU +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F350
  c misc: --c99
  c include: ..\..\..\..\..\Firmware\CMSIS\GD\GD32F3x0\Include;..\..\..\..\..\Firmware\GD32F3x0_standard_peripheral\Include;..\..\..\..\..\Firmware\CMSIS\GD\GD32F3x0\Include;..\..\..\..\..\Utilities;..\inc;..\..\..\..\..\Firmware\GD32F3x0_usbfs_driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../src/: app.c usb_delay.c dfu_core.c dfu_mal.c flash_if.c gd32f3x0_it.c
  group CMSIS
    ../../../../../Firmware/GD32F3x0_usbfs_driver/Source/: system_gd32f3x0.c
  group GD32F3x0_StdPeriph_Driver
    ../../../../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_timer.c gd32f3x0_usart.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_syscfg.c
  group GD32F350R_EVAL
    ../../../../../Utilities/: gd32f350r_eval.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group USB_Driver
    ../../../../../Firmware/GD32F3x0_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Doc
    ../: readme.txt
