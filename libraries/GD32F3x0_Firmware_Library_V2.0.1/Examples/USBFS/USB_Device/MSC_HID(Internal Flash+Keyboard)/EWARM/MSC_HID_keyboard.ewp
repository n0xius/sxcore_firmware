# IAR project MSC_HID_keyboard.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F350xB GD GD32F350xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F350
  ICCARM.CCIncludePath2: ..\..\..\..\..\Firmware\CMSIS\GD\GD32F3x0\Include; ..\..\..\..\..\Firmware\GD32F3x0_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F3x0_usbfs_driver\Include; ..\..\..\..\..\Utilities; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MSC_HID_keyboard.srec
  ILINK.IlinkOutputFile: USB_Keyboard.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F350xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f3x0_it.c hid_core.c main.c msc_hid_wrapper.c usb_delay.c usbd_bbb_scsi.c usbd_flash_access.c usbd_msc_core.c
  group CMSIS
    ../../../../../Firmware/GD32F3x0_usbfs_driver/Source/: system_gd32f3x0.c
  group Doc
    ../: readme.txt
  group GD32F3x0_EVAL
    ../../../../../Utilities/: gd32f350r_eval.c
  group GD32F3x0_Peripherals
    ../../../../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_ctc.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F3x0/Source/IAR/: startup_gd32f3x0.s
  group USB_Drivers
    ../../../../../Firmware/GD32F3x0_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
